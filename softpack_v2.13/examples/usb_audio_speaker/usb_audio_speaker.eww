<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sam9g15-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sam9g25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sam9g35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sam9x25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sam9x35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sama5d2-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sama5d4-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_sama5d3-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_audio_speaker_samv71-xplained.ewp</path>
  </project>
</workspace>
