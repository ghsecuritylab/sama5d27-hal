<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/can_sam9x25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_sam9x35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_sama5d2-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_sama5d27-som1-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_sama5d3-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_sama5d3-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_samv71-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/can_same70-xplained.ewp</path>
  </project>
</workspace>
