# IAR project can_sam9x25-ek.ewp, settings and files
configuration sam9x25-ek_sram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9X25 Atmel AT91SAM9X25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_SRAM; BOARD_CONSOLE_TX_PIN=PIN_USART0_TXD; BOARD_CONSOLE_RX_PIN=PIN_USART0_RXD; BOARD_CONSOLE_ADDR=USART0; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9X25; CONFIG_BOARD_SAM9X25_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_CAN; CONFIG_HAVE_CAN_BUS; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_SHDWC; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: can.bin
  ILINK.IlinkOutputFile: can.out
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sam9x25-ek_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; BOARD_CONSOLE_TX_PIN=PIN_USART0_TXD; BOARD_CONSOLE_RX_PIN=PIN_USART0_RXD; BOARD_CONSOLE_ADDR=USART0; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9X25; CONFIG_BOARD_SAM9X25_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_CAN; CONFIG_HAVE_CAN_BUS; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_SHDWC; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\ddram.icf
  group (top)
    ../../examples/can/: main.c
  group drivers
    ../../drivers/can/: can-bus.c can.c cand.c
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/irq/: aic2.c irq.c
    ../../drivers/mm/: cache.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_can.c
    ../../target/sam9xx5/: chip.c board_support.c board_sam9xx5-ek.c
    ../../target/sam9xx5/toolchain/iar/: cstartup.s
