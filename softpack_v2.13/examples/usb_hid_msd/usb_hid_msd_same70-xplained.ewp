# IAR project usb_hid_msd_same70-xplained.ewp, settings and files
configuration same70-xplained_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAME70; CONFIG_CHIP_SAME70Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAME70_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_LED; CONFIG_HAVE_USBHS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\samv71; ..\..\drivers; ..\..\lib; ..\..\lib\libsdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_hid_msd.bin
  ILINK.IlinkOutputFile: usb_hid_msd.out
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: reset_handler
configuration same70-xplained_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAME70; CONFIG_CHIP_SAME70Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAME70_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_LED; CONFIG_HAVE_USBHS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\ddram.icf
configuration same70-xplained_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_FLASH; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAME70; CONFIG_CHIP_SAME70Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAME70_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_LED; CONFIG_HAVE_USBHS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\flash.icf
  group (top)
    ../../examples/usb_hid_msd/: main.c main_descriptors.c
    ../../examples/usb_common/: main_usb_common.c
    ../../lib/libstoragemedia/: media.c media_ramdisk.c media_sdcard.c
  group libsdmmc
    ../../lib/libsdmmc/: sdmmc_api.c
  group usb
    ../../lib/usb/common/audio/: aud_requests.c
    ../../lib/usb/common/cdc/: cdc_requests.c
    ../../lib/usb/common/hid/: hid_requests.c hid_usages.c
    ../../lib/usb/common/: usb_requests.c usb_descriptors.c
    ../../lib/usb/device/composite/: cdc_audd_driver.c cdc_hidd_driver.c cdc_msd_driver.c dual_cdcd_driver.c hid_audd_driver.c hid_msd_driver.c
    ../../lib/usb/device/hid/: hidd_function.c hidd_keyboard_callbacks_leds_changed.c hidd_keyboard_driver.c hidd_keyboard_input_report.c hidd_keyboard.c hidd_keyboard_output_report.c hidd_mouse_driver.c hidd_transfer_driver.c
    ../../lib/usb/device/msd/: msd_driver.c msdd_state_machine.c msd_function.c msd_io_fifo.c msd_lun.c sbc_methods.c
    ../../lib/usb/device/: usbd.c usbd_callbacks.c usbd_driver.c usbd_driver_callbacks.c
  group drivers
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/extram/: ddram.c mpddrc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/irq/: irq.c nvic.c
    ../../drivers/led/: led.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/flash/: eefc.c flashd.c
    ../../drivers/peripherals/: bus.c matrix.c pmc.c pwmc.c rstc.c rtc.c slowclock_supc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c uart.c usart.c usartd.c
    ../../drivers/usb/: usbd_usbhs.c
  group arch
    ../../arch/arm/: mutex.c l1cache_scb.c mpu_armv7m.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_led.c
    ../../target/samv71/: chip.c board_support.c board_same70-xplained.c
    ../../target/samv71/toolchain/: cstartup.c
