# IAR project usb_hid_msd_sama5d4-xplained.ewp, settings and files
configuration sama5d4-xplained_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D44 Atmel ATSAMA5D44
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D4; CONFIG_CHIP_SAMA5D44; CONFIG_BOARD_SAMA5D4_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_H32MXDIV; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_XDMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SFC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_MODE_PERSIAN; CONFIG_HAVE_RTC_TAMPER; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_UDPHS; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_L2CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sama5d4; ..\..\drivers; ..\..\lib; ..\..\lib\libsdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_hid_msd.bin
  ILINK.IlinkOutputFile: usb_hid_msd.out
  ILINK.IlinkIcfFile: ..\..\target\sama5d4\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sama5d4-xplained_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D4; CONFIG_CHIP_SAMA5D44; CONFIG_BOARD_SAMA5D4_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_H32MXDIV; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_XDMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SFC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_MODE_PERSIAN; CONFIG_HAVE_RTC_TAMPER; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_UDPHS; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_L2CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\sama5d4\toolchain\iar\ddram.icf
  group (top)
    ../../examples/usb_hid_msd/: main.c main_descriptors.c
    ../../examples/usb_common/: main_usb_common.c
    ../../lib/libstoragemedia/: media.c media_ramdisk.c media_sdcard.c
  group libsdmmc
    ../../lib/libsdmmc/: sdmmc_api.c
  group usb
    ../../lib/usb/common/audio/: aud_requests.c
    ../../lib/usb/common/cdc/: cdc_requests.c
    ../../lib/usb/common/hid/: hid_requests.c hid_usages.c
    ../../lib/usb/common/: usb_requests.c usb_descriptors.c
    ../../lib/usb/device/composite/: cdc_audd_driver.c cdc_hidd_driver.c cdc_msd_driver.c dual_cdcd_driver.c hid_audd_driver.c hid_msd_driver.c
    ../../lib/usb/device/hid/: hidd_function.c hidd_keyboard_callbacks_leds_changed.c hidd_keyboard_driver.c hidd_keyboard_input_report.c hidd_keyboard.c hidd_keyboard_output_report.c hidd_mouse_driver.c hidd_transfer_driver.c
    ../../lib/usb/device/msd/: msd_driver.c msdd_state_machine.c msd_function.c msd_io_fifo.c msd_lun.c sbc_methods.c
    ../../lib/usb/device/: usbd.c usbd_callbacks.c usbd_driver.c usbd_driver_callbacks.c
  group drivers
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/irq/: aic5.c irq.c
    ../../drivers/led/: led.c
    ../../drivers/mm/: cache.c l2cache_l2cc.c
    ../../drivers/nvm/: sfc.c
    ../../drivers/nvm/nand/: nfc.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
    ../../drivers/usb/: usbd_udphs.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_led.c
    ../../target/sama5d4/: chip.c board_support.c board_sama5d4-xplained.c
    ../../target/sama5d4/toolchain/iar/: cstartup.s
