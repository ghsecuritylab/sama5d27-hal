# IAR project eth_lwip_same70-xplained.ewp, settings and files
configuration same70-xplained_ddram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAME70; CONFIG_CHIP_SAME70Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAME70_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_ETH; CONFIG_HAVE_GMAC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_TWI_AT24; CONFIG_DRV_AT24; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\samv71; ..\..\drivers; ..\..\lib; ..\..\lib\lwip; ..\..\lib\lwip\softpack\include; ..\..\lib\lwip\softpack\include\arch; ..\..\lib\lwip\src\include; ..\..\lib\lwip\src\include\lwip\priv
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eth_lwip.bin
  ILINK.IlinkOutputFile: eth_lwip.out
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: reset_handler
  group (top)
    ../../examples/eth_lwip/: main.c
  group lwip
    ../../lib/lwip/softpack/arch/: sys_arch.c
    ../../lib/lwip/softpack/netif/: ethif.c
    ../../lib/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lib/lwip/src/apps/httpd/: fs.c httpd.c
    ../../lib/lwip/src/apps/lwiperf/: lwiperf.c
    ../../lib/lwip/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c def.c sys.c tcp.c tcp_in.c tcp_out.c udp.c inet_chksum.c ip.c timeouts.c
    ../../lib/lwip/src/apps/snmp/: snmp_asn1.c snmp_mib2.c snmp_mib2_interfaces.c snmp_msg.c
    ../../lib/lwip/src/core/ipv4/: dhcp.c autoip.c etharp.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c
    ../../lib/lwip/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
    ../../lib/lwip/src/netif/ppp/: auth.c chap_ms.c chap-md5.c chap-new.c fsm.c ipcp.c lcp.c magic.c upap.c ppp.c pppoe.c vj.c
    ../../lib/lwip/src/netif/ppp/polarssl/: md5.c
  group drivers
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/extram/: ddram.c mpddrc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: irq.c nvic.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/i2c/: at24.c
    ../../drivers/nvm/flash/: eefc.c flashd.c
    ../../drivers/network/: ethd.c gmacd.c gmac.c phy.c
    ../../drivers/peripherals/: bus.c matrix.c pmc.c pwmc.c rstc.c rtc.c slowclock_supc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c l1cache_scb.c mpu_armv7m.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_eth.c board_twi.c
    ../../target/samv71/: chip.c board_support.c board_same70-xplained.c
    ../../target/samv71/toolchain/: cstartup.c
