<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/qt2_xpro_surface_sama5d2-ptc-ek.ewp</path>
  </project>
</workspace>
