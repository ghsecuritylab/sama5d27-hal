<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/qt1-xpro-selfcap_sama5d2-ptc-ek.ewp</path>
  </project>
</workspace>
