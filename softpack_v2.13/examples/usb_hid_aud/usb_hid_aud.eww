<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sam9g15-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sam9g25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sam9g35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sam9x25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sam9x35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sama5d2-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sama5d4-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_sama5d3-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usb_hid_aud_samv71-xplained.ewp</path>
  </project>
</workspace>
