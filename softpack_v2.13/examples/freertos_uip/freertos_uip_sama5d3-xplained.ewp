# IAR project freertos_uip_sama5d3-xplained.ewp, settings and files
configuration sama5d3-xplained_ddram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D36 Atmel ATSAMA5D36
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D3; CONFIG_CHIP_SAMA5D36; CONFIG_BOARD_SAMA5D3_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_LIB_UIP_WEBSERVER; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_DIFF_INPUT; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_PLLA_CHARGE_PUMP; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_DMAC; CONFIG_HAVE_DMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_ETH; CONFIG_HAVE_EMAC; CONFIG_HAVE_GMAC; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_PMIC_ACT8865; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sama5d3; ..\..\drivers; ..\..\lib; ..\..\lib\uip\source\sama5-specific; ..\..\lib\uip\source\uip_1.0; ..\..\lib\uip\source\uip_1.0\uip; ..\..\lib\uip\source\uip_1.0\apps\webserver; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Demo\Common\include; ..\..\lib\freertos\portable\sama5d3\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_uip.bin
  ILINK.IlinkOutputFile: freertos_uip.out
  ILINK.IlinkIcfFile: ..\..\target\sama5d3\toolchain\iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../examples/freertos_uip/: main.c
  group freertos
    ../../lib/freertos/portable/sama5d3/: port.c FreeRTOS_tick_config.c
    ../../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group uip
    ../../lib/uip/source/sama5-specific/: clock-arch.c eth_tapdev.c
    ../../lib/uip/source/uip_1.0/uip/: psock.c uip_arp.c uip.c uip-fw.c uiplib.c uip-neighbor.c
    ../../lib/uip/source/uip_1.0/apps/webserver/: httpd.c http-strings.c httpd-fs.c httpd-cgi.c
  group drivers
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: aic5.c irq.c
    ../../drivers/led/: led.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/nand/: nfc.c
    ../../drivers/network/: ethd.c emacd.c emac.c gmacd.c gmac.c phy.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/power/: act8865.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_eth.c board_led.c board_twi.c
    ../../target/sama5d3/: chip.c board_support.c board_sama5d3-xplained.c
    ../../lib/freertos/portable/sama5d3/iar/: cstartup_freertos.s portASM.s
