# IAR project ssc_dma_audio_samv71-xplained.ewp, settings and files
configuration samv71-xplained_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAMV71; CONFIG_CHIP_SAMV71Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAMV71_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_AUDIO; CONFIG_HAVE_SSC; CONFIG_HAVE_AUDIO_WM8904; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\samv71; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssc_dma_audio.bin
  ILINK.IlinkOutputFile: ssc_dma_audio.out
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: reset_handler
configuration samv71-xplained_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAMV71; CONFIG_CHIP_SAMV71Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAMV71_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_AUDIO; CONFIG_HAVE_SSC; CONFIG_HAVE_AUDIO_WM8904; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\ddram.icf
configuration samv71-xplained_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_FLASH; CONFIG_ARCH_ARMV7M; CONFIG_ARCH_ARM; CONFIG_SOC_SAMV71; CONFIG_CHIP_SAMV71; CONFIG_CHIP_SAMV71Q21; CONFIG_FLASH_2048KB; CONFIG_PACKAGE_144PIN; CONFIG_BOARD_SAMV71_XPLAINED; CONFIG_HAVE_PIO3; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM_ONLY; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_PMC_UPLLDIV2; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_XDMAC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SDRAM_IS42S16100E; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_AUDIO; CONFIG_HAVE_SSC; CONFIG_HAVE_AUDIO_WM8904; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_MPU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_NVIC; CONFIG_HAVE_EEFC; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_SERIALD_USART
  ILINK.IlinkIcfFile: ..\..\target\samv71\toolchain\iar\flash.icf
  group (top)
    ../../examples/ssc_dma_audio/: main.c
  group drivers
    ../../drivers/audio/: wm8904.c audio_device.c ssc.c
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/extram/: ddram.c mpddrc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: irq.c nvic.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/flash/: eefc.c flashd.c
    ../../drivers/peripherals/: bus.c matrix.c pmc.c pwmc.c rstc.c rtc.c slowclock_supc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c l1cache_scb.c mpu_armv7m.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c wav.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_audio.c board_twi.c
    ../../target/samv71/: chip.c board_support.c board_samv71-xplained.c
    ../../target/samv71/toolchain/: cstartup.c
