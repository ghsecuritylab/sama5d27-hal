# IAR project freertos_lwip_sam9g25-ek.ewp, settings and files
configuration sam9g25-ek_ddram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G25 Atmel AT91SAM9G25
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9G25; CONFIG_BOARD_SAM9G25_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_ETH; CONFIG_HAVE_EMAC; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_TWI_AT24; CONFIG_DRV_AT24; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers; ..\..\lib; ..\..\lib\lwip; ..\..\lib\lwip\softpack\include; ..\..\lib\lwip\softpack\include\arch; ..\..\lib\lwip\src\include; ..\..\lib\lwip\src\include\lwip\priv; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Demo\Common\include; ..\..\lib\freertos\portable\sam9xx5\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_lwip.bin
  ILINK.IlinkOutputFile: freertos_lwip.out
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../examples/freertos_lwip/: main.c
  group freertos
    ../../lib/freertos/portable/sam9xx5/: port.c FreeRTOS_tick_config.c
    ../../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group lwip
    ../../lib/lwip/softpack/arch/: sys_arch.c
    ../../lib/lwip/softpack/netif/: ethif.c
    ../../lib/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lib/lwip/src/apps/httpd/: fs.c httpd.c
    ../../lib/lwip/src/apps/lwiperf/: lwiperf.c
    ../../lib/lwip/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c def.c sys.c tcp.c tcp_in.c tcp_out.c udp.c inet_chksum.c ip.c timeouts.c
    ../../lib/lwip/src/apps/snmp/: snmp_asn1.c snmp_mib2.c snmp_mib2_interfaces.c snmp_msg.c
    ../../lib/lwip/src/core/ipv4/: dhcp.c autoip.c etharp.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c
    ../../lib/lwip/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
    ../../lib/lwip/src/netif/ppp/: auth.c chap_ms.c chap-md5.c chap-new.c fsm.c ipcp.c lcp.c magic.c upap.c ppp.c pppoe.c vj.c
    ../../lib/lwip/src/netif/ppp/polarssl/: md5.c
  group drivers
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: aic2.c irq.c
    ../../drivers/led/: led.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/i2c/: at24.c
    ../../drivers/network/: ethd.c emacd.c emac.c phy.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_eth.c board_led.c board_twi.c
    ../../target/sam9xx5/: chip.c board_support.c board_sam9xx5-ek.c
    ../../lib/freertos/portable/sam9xx5/iar/: cstartup_freertos.s portASM.s
