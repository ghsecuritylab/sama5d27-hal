# IAR project freertos_lwip_sama5d4-xplained.ewp, settings and files
configuration sama5d4-xplained_ddram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D44 Atmel ATSAMA5D44
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D4; CONFIG_CHIP_SAMA5D44; CONFIG_BOARD_SAMA5D4_XPLAINED; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_H32MXDIV; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_XDMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SFC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_MODE_PERSIAN; CONFIG_HAVE_RTC_TAMPER; CONFIG_HAVE_ETH; CONFIG_HAVE_GMAC; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_TWI_AT24; CONFIG_HAVE_PMIC_ACT8865; CONFIG_DRV_AT24; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_L2CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sama5d4; ..\..\drivers; ..\..\lib; ..\..\lib\lwip; ..\..\lib\lwip\softpack\include; ..\..\lib\lwip\softpack\include\arch; ..\..\lib\lwip\src\include; ..\..\lib\lwip\src\include\lwip\priv; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Demo\Common\include; ..\..\lib\freertos\portable\sama5d4\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_lwip.bin
  ILINK.IlinkOutputFile: freertos_lwip.out
  ILINK.IlinkIcfFile: ..\..\target\sama5d4\toolchain\iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../examples/freertos_lwip/: main.c
  group freertos
    ../../lib/freertos/portable/sama5d4/: port.c FreeRTOS_tick_config.c
    ../../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group lwip
    ../../lib/lwip/softpack/arch/: sys_arch.c
    ../../lib/lwip/softpack/netif/: ethif.c
    ../../lib/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lib/lwip/src/apps/httpd/: fs.c httpd.c
    ../../lib/lwip/src/apps/lwiperf/: lwiperf.c
    ../../lib/lwip/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c def.c sys.c tcp.c tcp_in.c tcp_out.c udp.c inet_chksum.c ip.c timeouts.c
    ../../lib/lwip/src/apps/snmp/: snmp_asn1.c snmp_mib2.c snmp_mib2_interfaces.c snmp_msg.c
    ../../lib/lwip/src/core/ipv4/: dhcp.c autoip.c etharp.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c
    ../../lib/lwip/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
    ../../lib/lwip/src/netif/ppp/: auth.c chap_ms.c chap-md5.c chap-new.c fsm.c ipcp.c lcp.c magic.c upap.c ppp.c pppoe.c vj.c
    ../../lib/lwip/src/netif/ppp/polarssl/: md5.c
  group drivers
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: aic5.c irq.c
    ../../drivers/led/: led.c
    ../../drivers/mm/: cache.c l2cache_l2cc.c
    ../../drivers/nvm/: sfc.c
    ../../drivers/nvm/i2c/: at24.c
    ../../drivers/nvm/nand/: nfc.c
    ../../drivers/network/: ethd.c gmacd.c gmac.c phy.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/power/: act8865.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_eth.c board_led.c board_twi.c
    ../../target/sama5d4/: chip.c board_support.c board_sama5d4-xplained.c
    ../../lib/freertos/portable/sama5d4/iar/: cstartup_freertos.s portASM.s
