<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/isi_sama5d4-ek.ewp</path>
  </project>
</workspace>
