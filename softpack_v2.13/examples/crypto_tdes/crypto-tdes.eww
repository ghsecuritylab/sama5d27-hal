<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d2-ptc-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d2-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d27-som1-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d4-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d4-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d3-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/crypto-tdes_sama5d3-xplained.ewp</path>
  </project>
</workspace>
