<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sam9g15-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sam9g25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sam9g35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sam9x25-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sam9x35-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sama5d2-ptc-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sama5d4-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sama5d4-xplained.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sama5d3-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/smc_nandflash_slc_sama5d3-xplained.ewp</path>
  </project>
</workspace>
