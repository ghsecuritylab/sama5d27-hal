# IAR project eth_sam9g35-ek.ewp, settings and files
configuration sam9g35-ek_sram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G35 Atmel AT91SAM9G35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9G35; CONFIG_BOARD_SAM9G35_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_ETH; CONFIG_HAVE_EMAC; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_TWI_AT24; CONFIG_DRV_AT24; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eth.bin
  ILINK.IlinkOutputFile: eth.out
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sam9g35-ek_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9G35; CONFIG_BOARD_SAM9G35_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_ETH; CONFIG_HAVE_EMAC; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_TWI_AT24; CONFIG_DRV_AT24; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\ddram.icf
  group (top)
    ../../examples/eth/: main.c mini_ip.c
  group drivers
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
    ../../drivers/irq/: aic2.c irq.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/i2c/: at24.c
    ../../drivers/network/: ethd.c emacd.c emac.c phy.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c board_eth.c board_twi.c
    ../../target/sam9xx5/: chip.c board_support.c board_sam9xx5-ek.c
    ../../target/sam9xx5/toolchain/iar/: cstartup.s
