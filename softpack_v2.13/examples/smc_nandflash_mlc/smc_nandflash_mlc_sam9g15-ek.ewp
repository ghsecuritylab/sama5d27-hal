# IAR project smc_nandflash_mlc_sam9g15-ek.ewp, settings and files
configuration sam9g15-ek_ddram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G15 Atmel AT91SAM9G15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.13"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9G15; CONFIG_BOARD_SAM9G15_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_NAND_FLASH; CONFIG_HAVE_PMECC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_SHDWC; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: smc_nandflash_mlc.bin
  ILINK.IlinkOutputFile: smc_nandflash_mlc.out
  ILINK.IlinkIcfFile: ..\..\target\sam9xx5\toolchain\iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../examples/smc_nandflash_mlc/: main.c
  group drivers
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/irq/: aic2.c irq.c
    ../../drivers/mm/: cache.c
    ../../drivers/nvm/nand/: nand_flash.c nand_flash_raw.c nand_flash_ecc.c nand_flash_skip_block.c nand_flash_onfi.c nand_flash_model.c nand_flash_model_list.c nand_flash_dma.c pmecc.c pmecc_gf_512.c pmecc_gf_1024.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/serial/: console.c seriald.c dbgu.c uart.c usart.c usartd.c
  group arch
    ../../arch/arm/: mutex.c fault_handlers.c l1cache_cp15.c mmu_cp15.c
  group utils
    ../../utils/: callback.c intmath.c rand.c trace.c syscalls.c timer.c
  group target
    ../../target/common/: board_console.c board_timer.c chip_common.c
    ../../target/sam9xx5/: chip.c board_support.c board_sam9xx5-ek.c
    ../../target/sam9xx5/toolchain/iar/: cstartup.s
