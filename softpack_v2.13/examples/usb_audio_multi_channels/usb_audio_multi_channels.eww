<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/usb_audio_multi_channels_sama5d2-xplained.ewp</path>
  </project>
</workspace>
